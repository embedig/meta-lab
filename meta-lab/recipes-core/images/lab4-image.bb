DESCRIPTION = "Lab4 for Artyz7 boards"
LICENSE = "MIT"

require petalinux-image-common.inc

CORE_IMAGE_EXTRA_INSTALL = "hello-git nano"
