DESCRIPTION = "Lab8 for Artyz7 boards"
LICENSE = "MIT"

require petalinux-image-common.inc

CORE_IMAGE_EXTRA_INSTALL = "nano screen spidev-test i2c-tools"
