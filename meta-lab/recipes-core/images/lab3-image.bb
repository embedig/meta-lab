DESCRIPTION = "Lab3 for Artyz7 boards"
LICENSE = "MIT"

require petalinux-image-common.inc
