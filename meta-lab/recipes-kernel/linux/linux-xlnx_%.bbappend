FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://kernel-misc.cfg"


